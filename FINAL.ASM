SW1 EQU P2.5
ORG 00H
	MOV TMOD,#02H
		MOV TH0,#-3
			MOV SCON,#50H
			SETB TR0
			SKIP2:JB SW1,NEXT
			MOV DPTR,#300H
			SJMP LN
			NEXT:MOV DPTR,#400H
			LN:CLR A
			MOVC A,@A+DPTR
			JZ SKIP2
			ACALL SEND
			INC DPTR
			SJMP LN
			SEND:MOV SBUF,A
			LOOP2:JNB TI,LOOP2
			CLR TI
			RET
			ORG 300H
					MESS: DB "HELLO",0
			ORG 400H
					MESS2: DB "WELCOME",0
					END
